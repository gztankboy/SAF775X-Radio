# Keil uVision project SAF775X_Radio.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SAF775X_Radio +hex
  AfterMake: .\moveHex.bat
  AfterMake: fromelf.exe --bin -o  ..\..\SAF775X_Radio.bin .\Objects\*.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F30X_HD, __FPU_USED, __FPU_PRESENT, __TARGET_FPU_VFP, ARM_MATH_CM4
  c include: ..\..\User;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\CMSIS;..\hardware;..\..\Firmware\CMSIS\Include;..\lib\FlashDB\inc;..\lib\FlashDB\port\fal\inc;..\lib;..\lib\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group cmsis
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group user
    ../: main.c gd32f30x_it.c systick.c init.c init.h ui.c ui.h func.c func.h
    ../../Firmware/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../: README.md
  group hardware
    ../hardware/: rds.c SAF775X.c SAF775X.h iic_sw.c iic_sw.h lcd.c lcd.h pic.c pic.h Dirana3BasicDSP.c Dirana3BasicDSP.h rtc.c rtc.h
  group font
    ../hardware/: font.h font8.c font16.c font12.c font20.c font24.c
  group SFUD
    ../lib/sfud/src/: sfud.c sfud_sfdp.c
    ../lib/sfud/port/: sfud_port.c
    ../lib/sfud/inc/: sfud.h sfud_cfg.h sfud_def.h sfud_flash_def.h
  group Fal
    ../lib/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c fal_flash_port.c
    ../lib/FlashDB/port/fal/inc/: fal.h fal_cfg.h fal_def.h
  group FlashDB
    ../lib/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ../lib/FlashDB/inc/: fdb_cfg.h fdb_def.h fdb_low_lvl.h flashdb.h
